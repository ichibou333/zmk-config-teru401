## boards/shields/teru4012/Kconfig.defconfig
```kconfig
if SHIELD_TERU4012

config ZMK_KEYBOARD_NAME
    default "teru401"

endif # SHIELD_TERU4012
```
